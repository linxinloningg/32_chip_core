# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Public;.\APP\led;.\APP\24Cxx;.\APP\beep;.\App\flash;.\App\iic;.\App\key;.\APP\tftlcd;.\App\spi;.\App\sram;.\App\tim;.\App\touch;.\Malloc;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\App\smg;.\EMWIN\Demo;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\UCOS_BSP;.\UCOSIII\uCOS_CONFIG;.\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\EMWIN\STemWin_Demo\Text_demo;.\EMWIN\STemWin_Demo\Number_demo;.\EMWIN\STemWin_Demo\Graph2D_demo;.\EMWIN\STemWin_Demo\Bitmap_demo;.\EMWIN\STemWin_Demo\Color_demo;.\EMWIN\STemWin_Demo\Memdev_demo;.\EMWIN\STemWin_Demo\Memdev_duan_demo;.\EMWIN\STemWin_Demo\Memdev_Auto_demo;.\EMWIN\STemWin_Demo\WM_redraw_demo;.\EMWIN\STemWin_Demo\WM_Fun_demo;.\EMWIN\STemWin_Demo\WM_cat_demo;.\EMWIN\STemWin_Demo\GUIBuilder;.\EMWIN\STemWin_Demo\Button;.\EMWIN\STemWin_Demo\ButtonBmp;.\EMWIN\STemWin_Demo\CheckBox;.\EMWIN\STemWin_Demo\DropDown;.\EMWIN\STemWin_Demo\Edit;.\EMWIN\STemWin_Demo\FrameWin;.\EMWIN\STemWin_Demo\GraphWIN_demo;.\EMWIN\STemWin_Demo\HeaderWIN_demo;.\EMWIN\STemWin_Demo\ICONVIEWWIN_demo;.\EMWIN\STemWin_Demo\Listbox_demo;.\EMWIN\STemWin_Demo\Listview_demo;.\EMWIN\STemWin_Demo\Listwheelwin_demo;.\EMWIN\STemWin_Demo\Menuwin_demo;.\EMWIN\STemWin_Demo\Messageboxwin_demo;.\EMWIN\STemWin_Demo\Multieditwin_demo;.\EMWIN\STemWin_Demo\Multipagewin_demo;.\EMWIN\STemWin_Demo\Progbarwin_demo;.\EMWIN\STemWin_Demo\Radiowin_demo;.\EMWIN\STemWin_Demo\Scrollbarwin_demo;.\EMWIN\STemWin_Demo\Sliderwin_demo;.\EMWIN\STemWin_Demo\Treeviewwin_demo;.\EMWIN\STemWin_Demo\Windowwin_demo;.\EMWIN\XBFDEMO;.\FATFS\FATFS_APP;.\FATFS;.\FATFS\option;.\APP\sd;.\EMWIN\TTFDEMO;.\EMWIN\STemWin\TRUETYPE;.\EMWIN\STemWinHZ;.\FONT;.\EMWIN\STemWin_Picture\BMP;.\EMWIN\STemWin_Picture\JPEG;.\EMWIN\STemWin_Picture\GIF;.\EMWIN\STemWin_Picture\PNG;.\EMWIN\STemWinPNG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c
  group APP
    ./APP/24Cxx/: 24cxx.c
    ./APP/flash/: flash.c
    ./APP/iic/: iic.c
    ./APP/led/: led.c
    ./APP/spi/: spi.c
    ./APP/sram/: sram.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/touch/: touch.c
    ./APP/key/: key.c
    ./APP/beep/: beep.c
    ./APP/sd/: sd.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
  group UCOSIII_BSP
    ./UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ./UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group EMWIN_CONFIG
    ./EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ./EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_LIB
    ./EMWIN/STemWin/Lib/: STemWin526_CM3_OS_Keil.lib
  group EMWIN_DEMO
    ./EMWIN/STemWin_Picture/BMP/: bmpdisplay.c
    ./EMWIN/STemWin_Picture/JPEG/: jpegdisplay.c
    ./EMWIN/STemWin_Picture/GIF/: gifdisplay.c
    ./EMWIN/STemWin_Picture/PNG/: pngdisplay.c
  group FATFS
    ./FATFS/: diskio.c ff.c
    ./FATFS/FATFS_APP/: fatfs_app.c
    ./FATFS/option/: cc936.c
  group FONT
    ./FONT/: font_show.c fontupd.c
  group STemWin_HZ
    ./EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_UC_EncodeNone.c GUICharPEx.c
  group STemWin_PNG
    ./EMWIN/STemWinPNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
