# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Public;.\APP\led;.\APP\24Cxx;.\APP\beep;.\App\flash;.\App\iic;.\App\key;.\APP\tftlcd;.\App\spi;.\App\sram;.\App\tim;.\App\touch;.\Malloc;.\EMWIN\STemWin\Config;.\EMWIN\STemWin\inc;.\App\smg;.\EMWIN\Demo
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c
  group APP
    ./APP/24Cxx/: 24cxx.c
    ./APP/flash/: flash.c
    ./APP/iic/: iic.c
    ./APP/led/: led.c
    ./APP/spi/: spi.c
    ./APP/sram/: sram.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/time/: time.c
    ./APP/touch/: touch.c
    ./APP/key/: key.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group Malloc
    ./Malloc/: malloc.c
